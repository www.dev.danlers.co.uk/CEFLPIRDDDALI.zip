Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: DANLERS CEFLPIRDALI-Pr_75_75_76_61 - Passive Infrared Sensors.IFC
Time: 2016-04-14T10:51:10
Written by: SwIFC
Made in: SolidWorks 2016

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 mm

# IfcBuildingElementProxy: CEFLPIRDALI-Ceiling Can Lid
In: Default Storey
PredefinedType: ELEMENT; Material: ABS PC
PSet_Type_Identity_Data - UniClass2 Number: Pr_75_75_76_61; UniClass2 Title: Passive Infrared Sensors

# IfcBuildingElementProxy: CEFLPIRDALI-Ceiling Can Moulding
In: Default Storey
PredefinedType: ELEMENT; Material: ABS PC
PSet_Type_Identity_Data - UniClass2 Number: Pr_75_75_76_61; UniClass2 Title: Passive Infrared Sensors
PSet_Mass_Property - Mass Measure: 47211399; Area Measure: 133748401 m2; Volume Measure: 47211396539 m3

# IfcBuildingElementProxy: CEFLPIRDALI-Lens
In: Default Storey
PredefinedType: ELEMENT; Material: PE High Density Film
PSet_Type_Identity_Data - UniClass2 Number: Pr_75_75_76_61; UniClass2 Title: Passive Infrared Sensors

# IfcBuildingElementProxy: CEFLPIRDALI-Trim Spindle (2)
In: Default Storey
PredefinedType: ELEMENT; Material: ABS PC
PSet_Type_Identity_Data - UniClass2 Number: Pr_75_75_76_61; UniClass2 Title: Passive Infrared Sensors

# IfcBuildingElementProxy: Revolve1
In: Default Storey
PredefinedType: ELEMENT; Material: Steel
PSet_Type_Identity_Data - UniClass2 Number: Pr_75_75_76_61; UniClass2 Title: Passive Infrared Sensors

# IfcBuildingElementProxy: Revolve2
In: Default Storey
PredefinedType: ELEMENT; Material: Steel
PSet_Type_Identity_Data - UniClass2 Number: Pr_75_75_76_61; UniClass2 Title: Passive Infrared Sensors
